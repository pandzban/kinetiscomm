# Keil uVision project kl25_comm.uvprojx, settings and files
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kl25_comm
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./: acdc.c assoc.c extra.c leds.c main.c pit.c tpm.c uart.c acdc.h assoc.h extra.h leds.h pit.h tpm.h uart.h transmission.c send.c send.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
